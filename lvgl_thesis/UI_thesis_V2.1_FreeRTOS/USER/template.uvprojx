# Keil uVision project template.uvprojx, settings and files
target LVGL_CONTROL (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c misc: --diag_suppress=68 --diag_suppress=111 --diag_suppress=550
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\RTC;..\HARDWARE\RTC;..\HARDWARE\WKUP;..\HARDWARE\ADC;..\HARDWARE\DAC;..\HARDWARE\DMA;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\HARDWARE\SPI;..\HARDWARE\TOUCH;..\HARDWARE\W25QXX;..\HARDWARE\TIMER;..\HARDWARE\SRAM;..\GUI;..\GUI\lvgl;..\GUI\lv_examples;..\GUI\lvgl_driver;..\GUI_APP;..\HARDWARE\BEEP;..\GUI_APP\FONT;..\GUI_APP\IMG;..\GUI_APP\WIN;..\DOC;..\FreeRTOS\include;..\FreeRTOS\portable;..\TraceAnalyzer\config;..\TraceAnalyzer\include;..\TraceAnalyzer\Jlink_RTT\include;..\TraceAnalyzer\Jlink_RTT\config;..\FreeRTOS\portable\RVDS\ARM_CM3;..\HARDWARE\CAN
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/TOUCH/: touch.c ctiic.c ft5206.c gt9xxx.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/SRAM/: sram.c
    ../HARDWARE/BEEP/: beep.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_can.c stm32f10x_iwdg.c
  group GUI
    ../GUI/lvgl/src/lv_core/: lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
    ../GUI/lvgl/src/lv_draw/: lv_draw.c lv_draw_arc.c lv_draw_basic.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_rect.c lv_draw_triangle.c lv_img_cache.c lv_img_decoder.c
    ../GUI/lvgl/src/lv_font/: lv_font.c lv_font_fmt_txt.c lv_font_roboto_12.c lv_font_roboto_16.c lv_font_roboto_22.c lv_font_roboto_28.c lv_font_unscii_8.c
    ../GUI/lvgl/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../GUI/lvgl/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_circ.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_task.c lv_templ.c lv_txt.c lv_utils.c
    ../GUI/lvgl/src/lv_objx/: lv_arc.c lv_bar.c lv_btn.c lv_btnm.c lv_calendar.c lv_canvas.c lv_cb.c lv_chart.c lv_cont.c lv_ddlist.c lv_gauge.c lv_img.c lv_imgbtn.c lv_kb.c lv_label.c lv_led.c lv_line.c lv_list.c lv_lmeter.c lv_mbox.c lv_objx_templ.c lv_page.c lv_preload.c lv_roller.c lv_slider.c lv_spinbox.c lv_sw.c lv_ta.c lv_table.c lv_tabview.c lv_tileview.c lv_win.c
    ../GUI/lvgl/src/lv_themes/: lv_theme.c lv_theme_alien.c lv_theme_default.c lv_theme_material.c lv_theme_mono.c lv_theme_nemo.c lv_theme_night.c lv_theme_templ.c lv_theme_zen.c
    ../GUI/lvgl_driver/: lv_port_disp.c lv_port_indev.c
  group GUI_APP
    ../GUI_APP/: gui_app.c
    ../GUI_APP/WIN/: login_win.c main_win.c calendar_win.c chart_win.c gauge_win.c progress_win.c
    ../GUI_APP/IMG/: weixin_img.c logo_img.c date_img.c chart_img.c gauge_img.c progress_img.c
    ../GUI_APP/FONT/: my_font.c
  group CAN
    ../HARDWARE/CAN/: can_config.c
  group FreeRTOS
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_Portable
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group TraceAnlyzer
    ../TraceAnalyzer/Jlink_RTT/: SEGGER_RTT.c trcStreamPort.c
    ../TraceAnalyzer/: trcAssert.c trcCounter.c trcDiagnostics.c trcEntryTable.c trcError.c trcEvent.c trcEventBuffer.c trcExtension.c trcHardwarePort.c trcHeap.c trcInternalEventBuffer.c trcInterval.c trcISR.c trcKernelPort.c trcMultiCoreEventBuffer.c trcObject.c trcPrint.c trcSnapshotRecorder.c trcStackMonitor.c trcStateMachine.c trcStaticBuffer.c trcStreamingRecorder.c trcString.c trcTask.c trcTimestamp.c
  group DOC
    ../DOC/: readMe.txt
