# Keil uVision project LVGL.uvprojx, settings and files
target LVGL_CONTROL (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c misc: --diag_suppress=68 --diag_suppress=111 --diag_suppress=550
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\RTC;..\HARDWARE\RTC;..\HARDWARE\WKUP;..\HARDWARE\ADC;..\HARDWARE\DAC;..\HARDWARE\DMA;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\HARDWARE\SPI;..\HARDWARE\TOUCH;..\HARDWARE\W25QXX;..\HARDWARE\TIMER;..\HARDWARE\SRAM;..\GUI;..\GUI\lvgl;..\HARDWARE\BEEP;..\DOC;..\FreeRTOS\include;..\FreeRTOS\portable;..\TraceAnalyzer\config;..\TraceAnalyzer\include;..\TraceAnalyzer\Jlink_RTT\include;..\TraceAnalyzer\Jlink_RTT\config;..\FreeRTOS\portable\RVDS\ARM_CM3;..\HARDWARE\CAN;..\LVGL\GUI\lvgl\examples\porting;..\LVGL\GUI\lvgl\src;..\LVGL\GUI;..\LVGL\GUI_APP\demos\keypad_encoder;..\LVGL\GUI_APP\demos;..\LVGL\GUI_APP\demos\stress
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/TOUCH/: touch.c ctiic.c ft5206.c gt9xxx.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/SRAM/: sram.c
    ../HARDWARE/BEEP/: beep.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_can.c stm32f10x_iwdg.c
  group CAN
    ../HARDWARE/CAN/: can_config.c
  group FreeRTOS
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_Portable
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group lvgl_porting
    ../LVGL/GUI/lvgl/examples/porting/: lv_port_indev.c lv_port_disp.c
  group lvgl_core
    ../LVGL/GUI/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group lvgl_draw
    ../LVGL/GUI/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../LVGL/GUI/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c
  group lvgl_extra
    ../LVGL/GUI/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../LVGL/GUI/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../LVGL/GUI/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../LVGL/GUI/lvgl/src/extra/libs/qrcode/: lv_qrcode.c
    ../LVGL/GUI/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../LVGL/GUI/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../LVGL/GUI/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../LVGL/GUI/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../LVGL/GUI/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../LVGL/GUI/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../LVGL/GUI/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../LVGL/GUI/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../LVGL/GUI/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../LVGL/GUI/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../LVGL/GUI/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../LVGL/GUI/lvgl/src/extra/widgets/led/: lv_led.c
    ../LVGL/GUI/lvgl/src/extra/widgets/list/: lv_list.c
    ../LVGL/GUI/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../LVGL/GUI/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../LVGL/GUI/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../LVGL/GUI/lvgl/src/extra/widgets/span/: lv_span.c
    ../LVGL/GUI/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../LVGL/GUI/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../LVGL/GUI/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../LVGL/GUI/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../LVGL/GUI/lvgl/src/extra/widgets/win/: lv_win.c
    ../LVGL/GUI/lvgl/src/extra/: lv_extra.c
    ../LVGL/GUI/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../LVGL/GUI/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../LVGL/GUI/lvgl/src/extra/layouts/grid/: lv_grid.c
  group lvgl_font
    ../LVGL/GUI/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group lvgl_gpu
    ../LVGL/GUI/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../LVGL/GUI/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
  group lvgl_hal
    ../LVGL/GUI/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lvgl_misc
    ../LVGL/GUI/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group lvgl_widgets
    ../LVGL/GUI/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group TraceAnlyzer
    ../TraceAnalyzer/Jlink_RTT/: SEGGER_RTT.c trcStreamPort.c
    ../TraceAnalyzer/: trcAssert.c trcCounter.c trcDiagnostics.c trcEntryTable.c trcError.c trcEvent.c trcEventBuffer.c trcExtension.c trcHardwarePort.c trcHeap.c trcInternalEventBuffer.c trcInterval.c trcISR.c trcKernelPort.c trcMultiCoreEventBuffer.c trcObject.c trcPrint.c trcSnapshotRecorder.c trcStackMonitor.c trcStateMachine.c trcStaticBuffer.c trcStreamingRecorder.c trcString.c trcTask.c trcTimestamp.c
  group DOC
    ../DOC/: readMe.txt
  group GUI_APP
    ../LVGL/GUI_APP/demos/keypad_encoder/: lv_demo_keypad_encoder.c
    ../LVGL/GUI_APP/demos/stress/: lv_demo_stress.c
    ../LVGL/GUI_APP/demos/stress/assets/: lv_font_montserrat_12_compr_az.c lv_font_montserrat_16_compr_az.c lv_font_montserrat_28_compr_az.c
